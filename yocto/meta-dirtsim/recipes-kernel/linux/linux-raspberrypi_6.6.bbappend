FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-snd-usb-audio-quirk-picade-max-audio.patch"
